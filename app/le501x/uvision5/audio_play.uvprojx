# Keil uVision project audio_play.uvprojx, settings and files
target audio_play (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: audio_play
  AfterMake: ..\..\..\LS_SDK\tools\le501x\after_build.bat @L ..\..\..\LS_SDK 402661376
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: LE501X
  c include: ..\..; ..\..\..\LS_SDK; ..\..\..\LS_SDK\peripheral\inc; ..\..\..\LS_SDK\peripheral\api; ..\..\..\LS_SDK\module\common; ..\..\..\LS_SDK\module\calendar; ..\..\..\LS_SDK\module\crc; ..\..\..\LS_SDK\module\debug; ..\..\..\LS_SDK\module\debug\RTT; ..\..\..\LS_SDK\module\static_buffer; ..\..\..\LS_SDK\module\tinyfs; ..\..\..\LS_SDK\module\tinycrypt\lib\include; ..\..\..\LS_SDK\module\micro-ecc; ..\..\..\LS_SDK\module\adpcm; ..\..\..\LS_SDK\module\ble; ..\..\..\LS_SDK\module\ble\prf; ..\..\..\LS_SDK\soc; ..\..\..\LS_SDK\soc\arm_cm; ..\..\..\LS_SDK\soc\arm_cm\cmsis; ..\..\..\LS_SDK\soc\arm_cm\le501x; ..\..\..\LS_SDK\soc\arm_cm\le501x\integration
  asm misc: --cpreproc --cpreproc_opts=-DLE501X
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\..\LS_SDK\soc\arm_cm\le501x\compiler\armcc\mcu.ld
  link misc: --datacompressor=off --diag_suppress=L6314,L6329
  group ..
    ../../audio_format/adpcm/: audio_format_adpcm.c audio_play_adpcm.c
    ../../audio_format/: audio_format_common.c
    ../../audio_format/pcm/: audio_play_pcm.c
    ../../: main.c
  group default
    ../../../LS_SDK/peripheral/inc/: adc_msp.h crc_msp.h dmac_msp.h flash_svcall.h i2c_misc.h i2c_msp.h lscache_msp.h lscrypt_msp.h lsecc_msp.h lsiwdg_msp.h lspdm_msp.h lspis_msp.h lsqspi.h lsqspi_msp.h lsqspiv2.h lsqspiv2_msp.h lstimer_msp.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_dmac_type.h reg_i2c_type.h reg_lcd_type.h reg_lsadc_type.h reg_lscache_type.h reg_lscrypt_type.h reg_lsecc_type.h reg_lsiwdg_type.h reg_lsqspi_type.h reg_lsqspiv2_type.h reg_lstrng_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_rtc_type.h reg_sha_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_uart_type.h reg_usb_type.h rtc_msp.h sha_msp.h spi_flash_int.h spi_msp.h ssi_misc.h ssi_msp.h trng_msp.h uart_misc.h uart_msp.h
    ../../../LS_SDK/module/adpcm/: adpcm.h
    ../../: api_implemented_by_user.h app_config.h audio_definition.h user_audio_api.h user_audio_config.h user_audio_config_for_lib.h
    ../../../LS_SDK/soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../../../LS_SDK/module/common/: async_call.h circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.h linked_async_framework.h sw_timer.h sw_timer_port.h
    ../../../LS_SDK/module/ble/: ble_common_api.h builtin_timer.h ls_24g.h ls_ble.h ls_mesh.h ls_sig_mesh.h ls_sig_mesh_provisioner.h ls_sys.h rssi_smoothing_algo.h
    ../../../LS_SDK/soc/arm_cm/le501x/integration/: calc_acc.h dmac_config.h gpio_mode.h modem_rf_le501x.h modem_rf_le501x_24g.h pis_config.h reg_base_addr.h reg_lptim.h reg_lsexti_type.h reg_lsgpio.h reg_lsgpio_type.h reg_mdm2.h reg_mdm2_type.h reg_rcc.h reg_rcc_type.h reg_rf.h reg_rf_type.h reg_syscfg.h reg_syscfg_type.h
    ../../../LS_SDK/peripheral/api/: calc_div.h HAL_def.h io_config.h lsadc.h lscache.h lscrc.h lscrypt.h lsdmac.h lsecc.h lsi2c.h lsiwdg.h lspatch.h lspdm.h lspis.h lsrtc.h lssha.h lsspi.h lsssi.h lstimer.h lstrng.h lsuart.h spi_flash.h
    ../../../LS_SDK/module/calendar/: calendar.h
    ../../../LS_SDK/soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h sdk_default_config.h systick.h
    ../../../LS_SDK/module/crc/: crc16.h
    ../../../LS_SDK/module/static_buffer/: fifo.h linked_buffer.h
    ../../../LS_SDK/soc/arm_cm/le501x/: flash_svcall_int.h le501x.h platform.h portmacro.h sleep.h sys_stat.h
    ../../../LS_SDK/soc/arm_cm/: instructions.h svcall.h swint_call_asm.h
    ../../../LS_SDK/module/debug/: log.h ls_dbg.h
    ../../../LS_SDK/module/ble/prf/: prf_ancs.h prf_bass.h prf_diss.h prf_fotas.h prf_hid.h
    ../../../LS_SDK/module/debug/RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../LS_SDK/module/tinyfs/: tinyfs.h tinyfs_config.h tinyfs_nvm.h tinyfs_write_cache.h
    ../../../LS_SDK/module/micro-ecc/: types.h uECC.h uECC_vli.h
  group libs
    ../../../LS_SDK/soc/arm_cm/le501x/bin/: lib_audio_play.o
  group module
    ../../../LS_SDK/module/adpcm/: adpcm.c
    ../../../LS_SDK/module/common/: async_call.c circular_doubly_linked_list.c common.c linked_async_framework.c sw_timer.c
    ../../../LS_SDK/module/ble/: ble_common_api.c
    ../../../LS_SDK/module/calendar/: calendar.c
    ../../../LS_SDK/module/crc/: crc16.c
    ../../../LS_SDK/module/static_buffer/: fifo.c linked_buffer.c
    ../../../LS_SDK/module/debug/: log.c ls_dbg.c
    ../../../LS_SDK/module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../LS_SDK/module/debug/RTT/: SEGGER_RTT.c
    ../../../LS_SDK/module/tinycrypt/lib/source/: sha256.c utils.c
    ../../../LS_SDK/module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
    ../../../LS_SDK/module/micro-ecc/: uECC.c
  group peripheral
    ../../../LS_SDK/peripheral/src/: adc_dma.c calc_div.c dmac.c flash_svcall.c lsadc.c lscache.c lscrypt.c lsecc.c lsi2c.c lsiwdg.c lspdm.c lspdm_dma.c lspis.c lsqspi.c lsrtc.c lsspi.c lsspi_dma.c lsssi.c lsssi_dma.c lstimer.c lstrng.c spi_flash.c spi_flash_lsqspi.c uart.c uart_dma.c
  group soc
    ../../../LS_SDK/soc/arm_cm/le501x/integration/: adc_msp.c calc_acc.c dmac_msp.c i2c_msp.c io_config.c lscache_msp.c lscrypt_msp.c lsecc_msp.c lsiwdg_msp.c lspdm_msp.c lspis_msp.c lsqspi_msp.c lstimer_msp.c modem_rf_le501x.c modem_rf_le501x_24g.c rtc_msp.c spi_msp.c ssi_msp.c trng_msp.c uart_msp.c
    ../../../LS_SDK/soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sw_timer_port.c sys_stat.c
    ../../../LS_SDK/soc/arm_cm/le501x/compiler/armcc/: delay_asm.S sleep_asm.S startup.S svcall_asm.S
    ../../../LS_SDK/soc/arm_cm/: svcall.c swint_handler.c systick.c
